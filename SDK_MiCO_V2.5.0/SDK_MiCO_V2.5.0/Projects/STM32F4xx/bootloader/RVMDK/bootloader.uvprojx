# Keil uVision project bootloader.uvprojx, settings and files
target MiCOKit-3288 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader.axf +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\bootloader\MiCOKit-3288\Obj_RVMDK\bootloader.axf --output ..\..\..\..\Build\bootloader\Output\MiCOKit-3288\bootloader.bin
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER BOOTLOADER NO_MICO_RTOS
  c misc: --diag_suppress=1,1293,68
  c include: ..\..\..\..\Bootloader;..\..\..\..\Board\MK3288;..\..\..\..\include;..\..\..\..\include\MicoDrivers;..\..\..\..\libraries\utilities;..\..\..\..\MICO\system;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M4;..\..\..\..\Platform\Cortex-M4\CMSIS;..\..\..\..\Platform\MCU;..\..\..\..\Platform\MCU\STM32F4xx\peripherals;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries;..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver;..\..\..\..\libraries\Drivers\spi_flash;..\..\..\..\libraries\Drivers\MiCOKit_EXT;..\..\..\..\libraries\Drivers\MiCOKit_EXT\key;..\..\..\..\Platform;..\..\..\..\libraries\Drivers;..\..\..\..\MICO\security
  memory RVCT4: ROM 0x800c000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Board\MK3288\bootloaderLinkerForKeil.sct
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c mico_config.h Update_for_OTA.c ymodem.c bootloader.h
  group Board/MiCOKit-3288
    ../../../../Board/MK3288/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3165
    ../../../../Board/MK3165/: platform.c platform.h platform_config.h
  group Include
    ../../../../include/: MICO.h MicoSRPServer.h Common.h Debug.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group Include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MICODriverNanoSecond.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Libraries/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c CheckSumUtils.h RingBufferUtils.c RingBufferUtils.h StringUtils.c StringUtils.h
  group MICO/system
    ../../../../MICO/system/: system.h
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c
  group Platform/Drivers/SPI_Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c
    ../../../../libraries/Drivers/spi_flash/: spi_flash_platform.c
  group Platform/Drivers/MiCOKit-EXT/sensors
    ../../../../libraries/Drivers/display/VGM128064/: AsciiLib.c oled.c
    ../../../../libraries/Drivers/keypad/gpio_button/: button.c
    ../../../../libraries/Drivers/motor/dc_motor/: dc_motor.c
    ../../../../libraries/Drivers/rgb_led/P9813/: hsb2rgb_led.c rgb_led.c
    ../../../../libraries/Drivers/sensor/light_adc/: light_sensor.c
    ../../../../libraries/Drivers/sensor/infrared_adc/: infrared_reflective.c
    ../../../../libraries/Drivers/sensor/DHT11/: DHT11.c
    ../../../../libraries/Drivers/sensor/BME280/: bme280.c bme280_user.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/MCU/STM32F4xx/RVMDK
    ../../../../Platform/MCU/STM32F4xx/RVMDK/: startup_stm32f4xx_bootloader_RVMDK.s
  group Platform/MCU/STM32F4xx/peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: system_stm32f4xx.c
  group Platform/MCU/STM32F4xx/peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: platform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group MiCO/RTOS
    ../../../../MICO/RTOS/NoRTOS/: rtos.c
target MiCOKit-3165 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: bootLoader.axf +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\bootloader\MiCOKit-3165\Obj_RVMDK\bootloader.axf --output ..\..\..\..\Build\bootloader\Output\MiCOKit-3165\bootloader.bin
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER BOOTLOADER NO_MICO_RTOS HSE_VALUE=26000000
  c misc: --diag_suppress=1,1293,68
  c include: ..\..\..\..\Bootloader;..\..\..\..\Board\MK3165;..\..\..\..\include;..\..\..\..\libraries\utilities;..\..\..\..\libraries\utilities\json_c;..\..\..\..\MICO\core;..\..\..\..\MICO\security;..\..\..\..\MICO\system;..\..\..\..\MICO\system\command_console;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M4;..\..\..\..\Platform\Cortex-M4\CMSIS;..\..\..\..\Platform\MCU\STM32F4xx\peripherals;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries;..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver;..\..\..\..\libraries\Drivers\spi_flash;..\..\..\..\libraries\Drivers;..\..\..\..\Platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Board\MK3165\bootloaderLinkerForKeil.sct
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
