# Keil uVision project demo.uvprojx, settings and files
target MiCOKit-3162 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo.axf +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\demo\MiCOKit-3162\Obj_RVMDK\demo.axf --output ..\..\..\..\Build\demo\Output\MiCOKit-3162\demo.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG
  c misc: --diag_suppress=1,1293,68
  c include: ..\..\..\..\Demos\helloworld;..\..\..\..\Board\MK3162;..\..\..\..\include;..\..\..\..\include\MicoDrivers;..\..\..\..\libraries\utilities;..\..\..\..\libraries\utilities\json_c;..\..\..\..\MICO\core;..\..\..\..\MICO\security;..\..\..\..\MICO\system;..\..\..\..\MICO\system\command_console;..\..\..\..\MICO\system\config_server;..\..\..\..\MICO\system\easylink;..\..\..\..\MICO\system\mdns;..\..\..\..\MICO\system\tftp_ota;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU;..\..\..\..\Platform\MCU\STM32F2xx\peripherals;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries;..\..\..\..\libraries\Drivers\spi_flash;..\..\..\..\libraries\Drivers;..\..\..\..\libraries\daemons\homekit_server;..\..\..\..\libraries\daemons\http_server;..\..\..\..\Platform
  memory RVCT4: ROM 0x800c000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Application
    ../../../../Demos/helloworld/: helloworld.c
  group Board/MiCOKit-3162
    ../../../../Board/MK3162/: platform.c platform.h platform_config.h
  group Board/MiCOKit-F205
    ../../../../Board/MKF205/: platform.c platform.h platform_config.h
  group Include
    ../../../../include/: MICO.h MicoSRPServer.h Common.h Debug.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group Include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MICODriverNanoSecond.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group Libraries/utilities/jscon_c
    ../../../../libraries/utilities/json_c/: arraylist.h bits.h config.h json_debug.h json.h json_inttypes.h json_object.h json_object_private.h json_tokener.h json_util.h linkhash.h printbuf.h arraylist.c json_debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group MICO/core
    ../../../../MICO/core/: mico_config.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_8801.a mxchipWNet_cm3_spi.a
    ../../../../MICO/core/RF driver/: wlan_firmware.c
  group MICO/security
    ../../../../MICO/security/Sodium/: Lib_Sodium.IAR.release.a
    ../../../../mico/security/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
    ../../../../mico/security/Curve25519/: curve25519-donna.c
    ../../../../mico/security/SRP_6a/: Lib_SRP6a.IAR.release.a
  group MICO/system
    ../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system.h system_factory_test.c system_misc.c
    ../../../../MICO/system/command_console/: mico_cli.c mico_cli.h
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c system_easylink_wac.c
    ../../../../MICO/system/mdns/: mico_mdns.c mico_mdns.h
    ../../../../MICO/system/tftp_ota/: tftp_ota.c tftp_ota.h tftpc.o tftp.h
    ../../../../mico/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../mico/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss_KEIL.a
    ../../../../mico/system/easylink/MFi_WAC/: Lib_MFi_WAC.IAR.release.a
    ../../../../mico/system/mdns/: system_discovery.c
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib memory_debugger.c
  group Platform/Drivers/MFiAuth
    ../../../../libraries/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/SPI_Flash
    ../../../../libraries/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/Drivers/Button
    ../../../../libraries/Drivers/keypad/gpio_button/: button.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F2xx
    ../../../../Platform/MCU/STM32F2xx/: platform_init.c
  group Platform/MCU/STM32F2xx/RVMDK
    ../../../../Platform/MCU/STM32F2xx/RVMDK/: startup_stm32f2xx_RVMDK.s
  group Platform/MCU/STM32F2xx/wlan_bus_driver
    ../../../../Platform/MCU/STM32F2xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group Platform/MCU/STM32F2xx/peripherals/Libraries
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/: system_stm32f2xx.c
  group Platform/MCU/STM32F2xx/peripherals
    ../../../../Platform/MCU/STM32F2xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c platform_nano_second.c
target MiCOKit-F205 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: as above
  output: demo.axf +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\demo\MiCOKit-F205\Obj_RVMDK\demo.axf --output ..\..\..\..\Build\demo\Output\MiCOKit-F205\demo.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG
  c misc: --diag_suppress=1,1293,68
  c include: ..\..\..\..\Demos\helloworld;..\..\..\..\include;..\..\..\..\include\MicoDrivers;..\..\..\..\libraries\utilities;..\..\..\..\libraries\utilities\json_c;..\..\..\..\Board\MKF205;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\Platform\MCU\STM32F2xx\peripherals;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries;..\..\..\..\MICO\core;..\..\..\..\MICO\security;..\..\..\..\MICO\system;..\..\..\..\MICO\system\command_console;..\..\..\..\MICO\system\config_server;..\..\..\..\MICO\system\easylink;..\..\..\..\MICO\system\mdns;..\..\..\..\MICO\system\tftp_ota;..\..\..\..\Platform;..\..\..\..\libraries\drivers\spi_flash
  memory RVCT4: ROM 0x8008000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
