# IAR project demo.ewp, settings and files
configuration MiCOKit-G55 (ARM)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel ATSAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; __SAMG55J19__; ARM_MATH_CM4=true; BOARD=USER_BOARD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\helloworld; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MKG55; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\services\flash_efc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pio; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\usart; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\rtt; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\supc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\matrix; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\spi; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\efc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pmc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pdc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\wdt; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\flexcom; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\ioport; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\clock; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\utils; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include\instance; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\preprocessor; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\header_files; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\sleepmgr; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\boards; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\twi; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\adc; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\drivers; ..\..\..\..\libraries\drivers\MiCOKit_EXT; ..\..\..\..\libraries\drivers\spi_flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MKG55\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../Demos/helloworld/: helloworld.c
  group Board/MiCOKit-G55
    ../../../../Board/MKG55/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: debug.h mico.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverNanoSecond.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group libraries/daemon/homekit_server
    ../../../../libraries/daemons/homekit_server/: Lib_HomeKit_Server.Cortex-M4.IAR.release.a
  group libraries/daemon/http_server
    ../../../../libraries/daemons/http_server/: http-strings.c http_parse.c httpd.c httpd_handle.c httpd_ssi.c httpd_sys.c httpd_wsgi.c
  group libraries/Drivers/display/VGM128064
    ../../../../libraries/drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group libraries/Drivers/keypad/gpio_button
    ../../../../libraries/drivers/keypad/gpio_button/: button.c button.h
  group libraries/Drivers/led/P9813
    ../../../../libraries/drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group libraries/Drivers/MFiAuth
    ../../../../libraries/drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group libraries/Drivers/MiCOKit-EXT
    ../../../../libraries/drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c motion_sensor.c motion_sensor.h temp_hum_sensor.c
  group libraries/Drivers/MiCOKit-STmem
    ../../../../libraries/drivers/MiCOKit_STmems/: MiCOKit_STmems.c MiCOKit_STmems.h MiCOKit_STmems_def.h
  group libraries/Drivers/motor/dc_motor
    ../../../../libraries/drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group libraries/Drivers/sensor/ADPS9930
    ../../../../libraries/drivers/sensor/apds9930/: APDS9930.c APDS9930.h
  group libraries/Drivers/sensor/BMA2x2
    ../../../../libraries/drivers/sensor/BMA2x2/: bma2x2.c bma2x2.h bma2x2_user.c bma2x2_user.h
  group libraries/Drivers/sensor/BME280
    ../../../../libraries/drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group libraries/Drivers/sensor/BMG160
    ../../../../libraries/drivers/sensor/BMG160/: bmg160.c bmg160.h bmg160_user.c bmg160_user.h
  group libraries/Drivers/sensor/BMM050
    ../../../../libraries/drivers/sensor/BMM050/: bmm050.c bmm050.h bmm050_user.c bmm050_user.h
  group libraries/Drivers/sensor/DHT11
    ../../../../libraries/drivers/sensor/DHT11/: DHT11.c DHT11.h
  group libraries/Drivers/sensor/HTS221
    ../../../../libraries/drivers/sensor/HTS221/: hts221.c hts221.h
  group libraries/Drivers/sensor/infrared_adc
    ../../../../libraries/drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group libraries/Drivers/sensor/light_adc
    ../../../../libraries/drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group libraries/Drivers/sensor/LPS25HB
    ../../../../libraries/drivers/sensor/LPS25HB/: lps25hb.c lps25hb.h
  group libraries/Drivers/sensor/LSM9DS1
    ../../../../libraries/drivers/sensor/LSM9DS1/: lsm9ds1.h lsm9ds1_acc_gyr.c lsm9ds1_mag.c
  group libraries/Drivers/sensor/UVIS25
    ../../../../libraries/drivers/sensor/UVIS25/: uvis25.c uvis25.h
  group libraries/Drivers/SPI Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c json_debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group mico/core
    ../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_spi.a
  group mico/security
    ../../../../MICO/security/Sodium/: Lib_Sodium.IAR.release.a
    ../../../../MICO/security/SRP_6a/: Lib_SRP6a.IAR.release.a
  group mico/security/curve25519
    ../../../../MICO/security/Curve25519/: curve25519-donna.c
  group mico/security/SHA
    ../../../../MICO/security/SHAUtils/: hkdf.c hmac.c sha-private.h sha.h sha1.c sha224-256.c sha384-512.c usha.c
  group mico/system
    ../../../../MICO/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MICO/system/easylink/MFi_WAC/: Lib_MFi_WAC.IAR.release.a
    ../../../../MICO/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss.a
    ../../../../MICO/system/command_console/: mico_cli.c
    ../../../../MICO/system/mdns/: mico_mdns.c system_discovery.c
    ../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system_factory_test.c system_misc.c
    ../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c system_easylink_wac.c
    ../../../../MICO/system/tftp_ota/: tftp_ota.c tftpc.o
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: close.c lseek.c remove.c Retarget.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/ATSAMG55
    ../../../../Platform/MCU/ATSAMG55/: platform_init.c
  group Platform/MCU/ATSAMG55/EWARM
    ../../../../Platform/MCU/ATSAMG55/EWARM/: startup_ATSAMG55_EWARM.s
  group Platform/MCU/ATSAMG55/Peripherals
    ../../../../Platform/MCU/ATSAMG55/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/common
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/common/utils/interrupt/: interrupt_sam_nvic.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/common/services/clock
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/services/clock/samg/: sysclk.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/common/services/sleepmgr
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/services/sleepmgr/sam/: sleepmgr.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/common/utils/interrupt
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/utils/interrupt/: interrupt_sam_nvic.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/adc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/adc/: adc2.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/efc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/efc/: efc.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/flexcom
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/flexcom/: flexcom.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/matrix
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/matrix/: matrix.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pdc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pdc/: pdc.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pio
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pio/: pio.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pmc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pmc/: pmc.c sleep.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/rtt
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/rtt/: rtt.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/spi
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/spi/: spi.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/supc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/supc/: supc.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/twi
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/twi/: twi.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/usart
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/usart/: usart.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/wdt
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/wdt/: wdt.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/services/flash_efc
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/services/flash_efc/: flash_efc.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/utils/cmsis
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group Platform/MCU/ATSAMG55/wlan_bus_driver
    ../../../../Platform/MCU/ATSAMG55/wlan_bus_driver/: wlan_bus_spi.c wlan_platform.c
